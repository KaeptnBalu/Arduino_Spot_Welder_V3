# Repository KaeptnBalu/Arduino_Spot_Welder_V3

File README.md:

# Arduino_Spot_Welder_V3

This is the latest V3 of the Arduino Spot Welder. The previous V2 can be found here https://github.com/KaeptnBalu/Arduino_Spot_Welder_V2

An Arduino based Spot Welder for battery welding 
- Build Guide: http://www.instructables.com/id/DIY-Arduino-Battery-Spot-Welder/
- Introduction Video: https://www.youtube.com/watch?v=CNmvx2JSCvA
- Project Homepage: https://malectrics.eu/

Improvements in V3:

- Mosfet PCB now with 2oz copper layer and wider traces which connect the high current carrying mosfet legs to the u-shaped aluminum part
- “AutoPulse” feature, which automatically activates a pulse after a defined delay time when both welding tips touch the nickel strip (thanks to Petr Zverina for the idea)
- 7 segment display replaced by OLED display
- potentiometer replaced by rotary encoder
- Menu system to easy adjust the low battery alarm, AutoPulse delay and short pulse time
- powered directly by car battery, no more need for extra power supply
- TVS diode integrated on the mosfet pcb, no external diodes necessary
- upgraded Mosfets to IRFB7430 (they can handle up to 1000A welding current with no problem)
- Standby feature: after 5 minutes of inactivity the Spot Welder will go to standby and the foot switch and AutoPulse will be deactivated while in standby.
- u-shaped aluminum parts is now riveted to the pcb

This Spot Welder can be used to weld 18650 batteries. It uses a 12V car battery as welding current supply. Typically one 40Ah 440A battery delivers enough current to get good welds with 0.15mm nickel strips and even 0.25mm nickel strips. For thicker nickel strips maybe you will need bigger battery or two in paralell.

The Welder generates a double pulse, where the first one is 12% of the time of the second one by default. Pulse time of the main pulse is adjustable by the rotary encoder and displayed on the screen in ms so you can exactly adjust the time. Its adjustable from 1 … 100 mS by default. (adjustable up to 500ms in the system menu)

If you want to download the project click on "clone or download" on this page. Downloading single files sometimes seems to cause some files to be corrupted while downloading.

You can get parts to build your own Spot Welder or prebuilt kits at https://malectrics.eu/

## KiCad design STM32/pcb/Spot_Welder.kicad_pcb

Parts:
C1, C6: 10u; C_0805_2012Metric
C2, C3: 1u; C_0603_1608Metric
C4: 470u; CP_Radial_D10.0mm_P5.00mm
C5, C8, C9, C10, C11, C12, C13: 10n; C_0603_1608Metric
C7: 22u; C_1206_3216Metric
C14, C15: 0.1u; C_0603_1608Metric
D1: TVS_SMDJ13A; D_SMC
D2: SS34; D_SMA
D3, D4: BZX84C3V6; D_SOT-23_ANK
FB1: Ferrite_Bead; L_0603_1608Metric
H3, H4, H5, H6: MountingHole; MountingHole_2.5mm
J1: SSD1306; Molex_KK-254_AE-6410-04A_1x04_P2.54mm_Vertical
J2: Debug; PinSocket_1x03_P2.54mm_Vertical
J5: Battery; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
J6: Foot_Switch; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical
R1, R8, R9, R11: 1k; R_0603_1608Metric
R2, R7, R10, R12: 100k; R_0603_1608Metric
R3, R5, R23: 10k; R_0603_1608Metric
R4, R6: 3.3k; R_0603_1608Metric
R21, R22: 4.7k; R_0603_1608Metric
SW1: RE; RotaryEncoder_Alps_EC12E-Switch_Vertical_H20mm_CircularMoun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
U2: STM32F030F4Px; TSSOP-20_4.4x6.5mm_P0.65mm
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: ZXGD3009E6; SOT-23-6
U12: AT24CS04-STUM; SOT-23-5

Connections:
3.3V_MCU: C1.1, C7.1, C14.1, FB1.1, J1.1, R2.2, R7.1, R10.2, R12.2, R21.1, R22.1, R23.2, U2.16 (VDD), U3.2 (VO), U12.8
12V_VCC: C3.1, C4.1, C5.1, C6.1, D2.1 (K), R3.1, U3.3 (VI), U4.2; also elsewhere on the board
+12V: D1.1 (K), D2.2 (A), J5.1
/VDDA: C15.1, FB1.2, U2.5 (VDDA)
ADC_Pulse: C10.1, D4.1 (K), R5.2, R6.1, U2.6 (PA0)
ADC_VIN: C9.1, D3.1 (K), R3.2, R4.1, U2.11 (PA5)
Encoder_A: C12.2, R9.2, U2.12 (PA6)
Encoder_B: C11.2, R8.2, U2.13 (PA7)
Encoder_Switch: C13.1, R11.1, R12.1, U2.14 (PB1)
Foot_Switch: C8.1, R1.1, R2.1, U2.10 (PA4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, D1.2 (A), D3.2 (A), D4.2 (A), J1.2, J2.3, J5.2, J6.2, R4.2, R6.2, SW1.C, SW1.S2, U2.1 (BOOT0), U2.15 (VSS), U3.1 (GND), U4.4, U12.1, U12.2, U12.3, U12.4, U12.7; also elsewhere on the board
Gate_Drive: U4.5; also elsewhere on the board
MCU_Gate: U2.7 (PA1), U4.3
unnamed: C2.1, R23.1, U2.4 (NRST)
unnamed: J6.1, R1.2
unnamed: R7.2, R8.1, SW1.B
unnamed: R9.1, R10.1, SW1.A
unnamed: R11.2, SW1.S1
OUT-: R5.1; also elsewhere on the board
SCL: J1.3, R21.2, U2.17 (PA9), U12.6
SDA: J1.4, R22.2, U2.18 (PA10), U12.5
SWCLK: J2.2, U2.20 (PA14)
SWDIO: J2.1, U2.19 (PA13)

Notes on the sheet:
Input Stage
3.3V Supply
MOSFET Gate Drive
Input Voltage Measurement
Auto Pulse Section
Rotary Encoder
Foot Switch
OLED
EEPROM
Power Flags

Parts:
D5, D7, D8, D9, D10, D11, D12, D13: DDS9705S; D_SOD-123
D6: TVS_SMAJ13A; D_SMA
D14, D15, D16, D17, D18, D19, D20, D21: TVS_SMDJ13A; D_SMC
H1, H2, H7, H8, H9, H10, H11, H12: MountingHole_Pad; MountingHole_6mm_Pad_Via
R13, R14, R15, R16, R17, R18, R19, R20: 22; R_0603_1608Metric
U1, U5, U6, U7, U8, U9, U10, U11: HY4903B6; TO-263-6

Connections:
GND: D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), H9.1, H10.1, H11.1, H12.1, U1.2 (S), U1.3 (S), U1.5 (S), U1.6 (S), U1.7 (S), U5.2 (S), U5.3 (S), U5.5 (S), U5.6 (S), U5.7 (S), U6.2 (S), U6.3 (S), U6.5 (S), U6.6 (S), U6.7 (S), U7.2 (S), U7.3 (S), U7.5 (S), U7.6 (S), U7.7 (S), U8.2 (S), U8.3 (S), U8.5 (S), U8.6 (S), U8.7 (S), U9.2 (S), U9.3 (S), U9.5 (S), U9.6 (S), U9.7 (S), U10.2 (S), U10.3 (S), U10.5 (S), U10.6 (S), U10.7 (S), U11.2 (S), U11.3 (S), U11.5 (S), U11.6 (S), U11.7 (S); also elsewhere on the board
Gate_Drive: D6.1 (K), R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2; also elsewhere on the board
unnamed: D5.1 (K), R13.1, U1.1 (G)
unnamed: D7.1 (K), R14.1, U5.1 (G)
unnamed: D8.1 (K), R15.1, U6.1 (G)
unnamed: D9.1 (K), R16.1, U7.1 (G)
unnamed: D10.1 (K), R17.1, U8.1 (G)
unnamed: D11.1 (K), R18.1, U9.1 (G)
unnamed: D12.1 (K), R19.1, U10.1 (G)
unnamed: D13.1 (K), R20.1, U11.1 (G)
OUT-: D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), H1.1, H2.1, H7.1, H8.1, U1.4 (D), U5.4 (D), U6.4 (D), U7.4 (D), U8.4 (D), U9.4 (D), U10.4 (D), U11.4 (D); also elsewhere on the board

Notes on the sheet:
Battery
300A Fuse
OUT+

Board: 2 copper layers, 100.0 x 90.0 mm, 90 parts (24 on the bottom side), 31 nets.

Other parts of the board:
C16: 10u; C_0805_2012Metric

Their connections:
12V_VCC: C16.2; also elsewhere on the board
GND: C16.1; also elsewhere on the board

## KiCad design KiCad_PCB_Files/Kicad Project/Kicad Project V3.3/Arduino_Spot_Welder.kicad_pcb

File KiCad_PCB_Files/Kicad Project/Kicad Project V3.3/Readme.md:

This is the Kicad Project for the Arduino Spot Welder V3.3

Board: 2 copper layers, 110.0 x 60.0 mm, 58 parts (4 on the bottom side), 36 nets.

Parts:
C1, C3, C4, C6: 10nF; C_1210_HandSoldering
C2: 1µF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C5: 470µF; CP_Elec_10x10
D1: D; D_SMA_Handsoldering
D3: ZENER; D_SOD-123
D4: D_Schottky_BAV99; SOT-23
ENC1: Bourns_PEC11L; ALPS_STEC12E08
Foot_Switch1: CONN_01X02; Molex_KK-6410-02_02x2.54mm_Straight
Mosfet_CTRL1, Mosfet_CTRL2: CONN_01X08; Pin_Header_Straight_1x08_Pitch2.54mm_Large_Pads
P1: MCP1407; DIP-8_W7.62mm_Socket_LongPads
P2, P4: GND_con; Pin_Header_Straight_1x02_Pitch2.54mm
P3, P5: AutoPulse; Pin_Header_Straight_1x02_Pitch2.54mm
P6: OLED_Display; OLED_SSD1306_128x64
P7: V IN; Terminal_Block_2P_3.5mm
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: IRFB_7430; TO-220__long_Neutral123_Horizontal_LargePads
R1: 1k; R_1206_HandSoldering
R2, R3, R4, R5, R6, R7, R8, R9, R17, R18, R19, R20, R21, R22, R23, R24: 30; R_1206_HandSoldering
R10: 620; R_1206_HandSoldering
R11: 3.3k; R_1206_HandSoldering
R12, R13, R14, R15, R16: 10k; R_1206_HandSoldering
TVS1, TVS2, TVS3, TVS4: 5.0SMDJ13A; D_SMC_Handsoldering
TVS5: SMAJ13A; D_SMA
U1: arduino_nano; arduino_mini

Connections:
+5V: D4.2, P6.2, R13.1, R16.2, U1.12
+12V: D1.2, P7.2, R12.2
/A0: C6.2, D4.3, R11.2, R12.1, U1.4
/D2: C3.1, R15.1, U1.20
/D3: D3.1, R10.2, U1.21
/D5: P1.2, U1.23
/D6: ENC1.SW2, U1.24
/D7: Foot_Switch1.1, U1.25
/D8: C4.1, R14.1, U1.26
/Probe: P5.2, Q1.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, Q7.2, Q8.2, TVS1.1, TVS2.1, TVS3.1, TVS4.1
/SCL: P6.3, U1.9
/SDA: P6.4, U1.8
/Vin: C1.1, C2.1, C5.1, D1.1, P1.1, P1.8, U1.15
/battery_minus: P4.1, P4.2, P5.1, Q1.3, Q2.3, Q3.3, Q4.3, Q5.3, Q6.3, Q7.3, Q8.3, TVS1.2, TVS2.2, TVS3.2, TVS4.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, D3.2, D4.1, ENC1.C, ENC1.SW1, Foot_Switch1.2, P1.4, P1.5, P2.1, P2.2, P3.1, P6.1, P7.1, R1.2, R11.1, TVS5.2, U1.14, U1.19
unnamed: ENC1.A, R13.2, R14.2
unnamed: ENC1.B, R15.2, R16.1
unnamed: Mosfet_CTRL1.1, R17.2
unnamed: Mosfet_CTRL1.2, R18.2
unnamed: Mosfet_CTRL1.3, R19.2
unnamed: Mosfet_CTRL1.4, R20.2
unnamed: Mosfet_CTRL1.5, R21.2
unnamed: Mosfet_CTRL1.6, R22.2
unnamed: Mosfet_CTRL1.7, R23.2
unnamed: Mosfet_CTRL1.8, R24.2
unnamed: Mosfet_CTRL2.1, Mosfet_CTRL2.2, Mosfet_CTRL2.3, Mosfet_CTRL2.4, Mosfet_CTRL2.5, Mosfet_CTRL2.6, Mosfet_CTRL2.7, Mosfet_CTRL2.8, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2
unnamed: P1.6, P1.7, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, TVS5.1
unnamed: P3.2, R1.1, R10.1
unnamed: Q1.1, R2.1
unnamed: Q2.1, R3.1
unnamed: Q3.1, R4.1
unnamed: Q4.1, R5.1
unnamed: Q5.1, R6.1
unnamed: Q6.1, R7.1
unnamed: Q7.1, R8.1
unnamed: Q8.1, R9.1

## KiCad design KiCad_PCB_Files/Kicad Project/Kicad Project V3.1/Arduino_Spot_Welder.kicad_pcb

File KiCad_PCB_Files/Kicad Project/Kicad Project V3.1/README.md:

This is the Kicad project for V3.1
The Arduino Board was not changed, only the Mosfet Board got a updgrade.

Parts:
C1: 0.1µF; C_1210_HandSoldering
C2: 1µF; C_Disc_D7.5mm_W5.0mm_P5.00mm
C3, C4, C6: 10nF; C_1210_HandSoldering
C5: 470µF; CP_Elec_10x10
D1: D; D_SMA_Handsoldering
D3: ZENER; D_MiniMELF_Handsoldering
D4: D_Schottky_BAV99; SOT-23
D_M1, D_M2, D_M3, D_M4, D_M5, D_M6, D_M7, D_M8: TVS-SMAJ13A-13-F; D_SMA
ENC1: Bourns_PEC11L; ALPS_STEC12E08
Foot_Switch1: CONN_01X02; Molex_KK-6410-02_02x2.54mm_Straight
Mosfet_CTRL1, Mosfet_CTRL2: CONN_01X08; Pin_Header_Straight_1x08_Pitch2.54mm_Large_Pads
P1: MCP1407; DIP-8_W7.62mm_Socket_LongPads
P2, P4: GND_con; Pin_Header_Straight_1x02_Pitch2.54mm
P3, P5: AutoPulse; Pin_Header_Straight_1x02_Pitch2.54mm
P6: OLED_Display; OLED_SSD1306_128x64
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: IRFB_7430; TO-220__long_Neutral123_Horizontal_LargePads
R1: 150; R_2512_HandSoldering
R2, R3, R4, R5, R6, R7, R8, R9: 30; R_1206_HandSoldering
R10: 620; R_1206_HandSoldering
R11: 3.3k; R_1206_HandSoldering
R12, R13, R14, R15, R16: 10k; R_1206_HandSoldering
TVS1, TVS2, TVS3, TVS4: 5.0SMDJ13A; D_SMC_Handsoldering
U1: arduino_nano; arduino_mini
W1: GND; SolderWirePad_single_1mmDrill
W2: 12V; SolderWirePad_single_1mmDrill

Connections:
+5V: D4.2 (K), P6.2, R13.1, R16.2, U1.12 (5V)
+12V: D1.2 (A), W2.1
/A0: C6.2, D4.3 (common), R11.2, R12.1, U1.4 (A0)
/D2: C3.1, R15.1, U1.20 ((int2)D2)
/D3: D3.1 (K), R10.2, U1.21 ((int3)#D3)
/D5: P1.2, U1.23 (#D5)
/D6: ENC1.SW2 (PB), U1.24 (#D6)
/D7: Foot_Switch1.1, U1.25 (D7)
/D8: C4.1, R14.1, U1.26 (D8)
/Probe: P5.2, Q1.2 (D), Q2.2 (D), Q3.2 (D), Q4.2 (D), Q5.2 (D), Q6.2 (D), Q7.2 (D), Q8.2 (D), TVS1.1 (K), TVS2.1 (K), TVS3.1 (K), TVS4.1 (K)
/SCL: P6.3, U1.9 (A5(SCL))
/SDA: P6.4, U1.8 (A4(SDA))
/Vin: C1.1, C2.1, C5.1, D1.1 (K), P1.1, P1.8, R12.2, U1.15 (Vin)
/battery_minus: D_M1.2 (A), D_M2.2 (A), D_M3.2 (A), D_M4.2 (A), D_M5.2 (A), D_M6.2 (A), D_M7.2 (A), D_M8.2 (A), P4.1, P4.2, P5.1, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), Q7.3 (S), Q8.3 (S), TVS1.2 (A), TVS2.2 (A), TVS3.2 (A), TVS4.2 (A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, D3.2 (A), D4.1 (A), ENC1.C, ENC1.SW1 (PB), Foot_Switch1.2, P1.4, P1.5, P2.1, P2.2, P3.1, P6.1, R1.2, R11.1, U1.14 (GND), U1.19 (GND), W1.1
unnamed: D_M1.1 (K), Mosfet_CTRL2.8, Q1.1 (G)
unnamed: D_M2.1 (K), Mosfet_CTRL2.7, Q2.1 (G)
unnamed: D_M3.1 (K), Mosfet_CTRL2.6, Q3.1 (G)
unnamed: D_M4.1 (K), Mosfet_CTRL2.5, Q4.1 (G)
unnamed: D_M5.1 (K), Mosfet_CTRL2.4, Q5.1 (G)
unnamed: D_M6.1 (K), Mosfet_CTRL2.3, Q6.1 (G)
unnamed: D_M7.1 (K), Mosfet_CTRL2.2, Q7.1 (G)
unnamed: D_M8.1 (K), Mosfet_CTRL2.1, Q8.1 (G)
unnamed: ENC1.A, R13.2, R14.2
unnamed: ENC1.B, R15.2, R16.1
unnamed: Mosfet_CTRL1.1, R2.1
unnamed: Mosfet_CTRL1.2, R3.1
unnamed: Mosfet_CTRL1.3, R4.1
unnamed: Mosfet_CTRL1.4, R5.1
unnamed: Mosfet_CTRL1.5, R6.1
unnamed: Mosfet_CTRL1.6, R7.1
unnamed: Mosfet_CTRL1.7, R8.1
unnamed: Mosfet_CTRL1.8, R9.1
unnamed: P1.6, P1.7, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2
unnamed: P3.2, R1.1, R10.1

Notes on the sheet:
Arduino Board Schematic
Mosfet Board Schematic
Auto Pulse Section
OLED Display Connection
Rotary Encoder Section
Input Voltage Measurement

Board: 2 copper layers, 110.0 x 60.0 mm, 58 parts (4 on the bottom side), 35 nets.

## Code that names these connections

File STM32/firmware/Spot_Welder.ioc (part):

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Mcu.Name=STM32F030F4Px
Mcu.Package=TSSOP20
Mcu.UserName=STM32F030F4Px
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=Auto_Pulse_In
PA0.Signal=GPIO_Input
PA1.GPIOParameters=GPIO_Speed,GPIO_Label
PA1.GPIO_Label=Gate_Driver
PA1.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PA1.Signal=GPIO_Output
PA10.Signal=GPIO_Input
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_SWCLK
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=Foot_Switch
PA4.Signal=GPIO_Input
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=ADC_VIN
PA5.Mode=IN5
PA5.Signal=ADC_IN5
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=ENCDR_B
PA6.Signal=GPIO_Input
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=ENCDR_A
PA7.Signal=GPIO_Input
PA9.GPIOParameters=GPIO_Speed,GPIO_FMA9
PA9.GPIO_FMA9=__NULL
PA9.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PA9.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=ENCDR_Switch
PB1.Signal=GPIO_Input
RCC.SYSCLKFreq_VALUE=48000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File STM32/firmware/Inc/main.h:

/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.h
  * @brief          : Header for main.c file.
  *                   This file contains the common defines of the application.
  ******************************************************************************
  * @attention
  *
  * <h2><center>&copy; Copyright (c) 2019 STMicroelectronics.
  * All rights reserved.</center></h2>
  *
  * This software component is licensed by ST under BSD 3-Clause license,
  * the "License"; You may not use this file except in compliance with the
  * License. You may obtain a copy of the License at:
  *                        opensource.org/licenses/BSD-3-Clause
  *
  ******************************************************************************
  */
/* USER CODE END Header */

/* Define to prevent recursive inclusion -------------------------------------*/
#ifndef __MAIN_H
#define __MAIN_H

#ifdef __cplusplus
extern "C" {
#endif

/* Includes ------------------------------------------------------------------*/
#include "stm32f0xx_hal.h"

/* Private includes ----------------------------------------------------------*/
/* USER CODE BEGIN Includes */

/* USER CODE END Includes */

/* Exported types ------------------------------------------------------------*/
/* USER CODE BEGIN ET */

/* USER CODE END ET */

/* Exported constants --------------------------------------------------------*/
/* USER CODE BEGIN EC */

/* USER CODE END EC */

/* Exported macro ------------------------------------------------------------*/
/* USER CODE BEGIN EM */

/* USER CODE END EM */

/* Exported functions prototypes ---------------------------------------------*/
void Error_Handler(void);

/* USER CODE BEGIN EFP */

/* USER CODE END EFP */

/* Private defines -----------------------------------------------------------*/
#define ADC_Auto_Pulse_Pin GPIO_PIN_0
#define ADC_Auto_Pulse_GPIO_Port GPIOA
#define MCU_Gate_Pin GPIO_PIN_1
#define MCU_Gate_GPIO_Port GPIOA
#define Foot_Switch_Pin GPIO_PIN_4
#define Foot_Switch_GPIO_Port GPIOA
#define ADC_VIN_Pin GPIO_PIN_5
#define ADC_VIN_GPIO_Port GPIOA
#define Encoder_A_Pin GPIO_PIN_6
#define Encoder_A_GPIO_Port GPIOA
#define Encoder_B_Pin GPIO_PIN_7
#define Encoder_B_GPIO_Port GPIOA
#define Encoder_Switch_Pin GPIO_PIN_1
#define Encoder_Switch_GPIO_Port GPIOB
/* USER CODE BEGIN Private defines */

/* USER CODE END Private defines */

#ifdef __cplusplus
}
#endif

#endif /* __MAIN_H */

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/

## Commit log

2017-08-31 Create Mouser.com Shopping Cart V3
2017-09-01 Create Arduino PCB
2017-09-08 added little bit bigger tolerances
2017-12-03 Rename Mouser Shopping Cart V3.1 to Mouser.com Shopping Cart V3.1
2018-10-16 move Arduino source code to sub folder (required by Arduino IDE)
2018-10-16 add DEBUG switch
2018-10-16 fix input configuration, add debounce delays
2018-10-16 add pulse mode: active high (default) or active low
2018-10-16 fix spelling
2018-10-16 enable menu in low battery state
2018-10-16 reduce EEPROM write count
2019-08-22 using stm32f030 mcu
2019-10-01 pcb update
2019-10-03 pcb complete
2019-10-03 schematic pdf
2019-10-17 eeprom footprint changed
2019-11-12 staring firmware
2019-11-13 flash memeory shortage (: (:
2019-11-14 menu update
2019-11-14 using soft i2c saved 6k
2019-11-14 adc check
2019-11-15 menu code opti
2019-11-15 flag variables opti
2019-11-15 git ignore
2019-11-15 implement auto pulse
2019-11-15 menu fun rename
2019-11-16 eeprom fun added
2019-11-16 short pulse added
2019-11-16 gate driver changed to mcp1416
2019-11-16 encoder reset count
2019-11-16 added images
2019-11-16 weld counter fun added
2019-11-16 minor reformating
2019-11-16 added schematic and sample images in STM32/images
2019-11-16 added reset to default fun
2019-11-16 added timeout in encoder read function
2019-11-21 main pulse and shrt can be set to zero
2019-11-21 menu enter functions renamed
2019-11-21 menu strings moved to different file
2019-11-23 menu code reformate
2020-03-30 Setup PlatformIO
2020-03-30 Resetting Repo
2020-03-30 Fix variable value update typo.
2020-03-30 Fixed type casting issue
